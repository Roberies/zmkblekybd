## boards/shields/breadboard_test/Kconfig.defconfig
```kconfig
if SHIELD_BREADBOARD_TEST

config ZMK_KEYBOARD_NAME
    default "Breadboard Test"

endif
```
